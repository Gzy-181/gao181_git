# Keil uVision project freertos_test.uvprojx, settings and files
target freertos_test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: freertos_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;D:/freertostemp/Inc1;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F1xx_HAL_Driver/Inc;..\extern;..\Drivers\SYSTEM\delay;..\Drivers\SYSTEM\sys;..\Drivers\SYSTEM\uart1;..\Drivers\BSP\bh1750;..\Drivers\BSP\adc;..\Drivers\BSP\bmp280;..\Drivers\BSP\oled;..\Drivers\BSP\my_iic;..\Drivers\BSP\rain_sensor;..\Drivers\BSP\dht22;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\BSP\timer;..\Drivers\BSP\dwt_delay
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
    ../Drivers/SYSTEM/delay/: delay.c delay.h
    ../Drivers/SYSTEM/sys/: main.h sys.c sys.h
    ../Drivers/SYSTEM/uart1/: uart1.c uart1.h
    ../Drivers/BSP/bh1750/: bh1750.c bh1750.h
    ../Drivers/BSP/adc/: adc.c adc.h
    ../Drivers/BSP/bmp280/: bmp280.c bmp280.h
    ../Drivers/BSP/dht22/: dht22.c dht22.h
    ../Drivers/BSP/oled/: oled.c oled.h oled_font.h
    ../Drivers/BSP/rain_sensor/: bsp_raindrop.c bsp_raindrop.h
    ../Drivers/BSP/timer/: timer.c timer.h
    ../Drivers/BSP/my_iic/: my_iic.c my_iic.h
    ../Drivers/BSP/dwt_delay/: dwt_delay.c dwt_delay.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
