# Keil uVision project stm32f103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\uart1;..\..\Drivers\BSP\led;..\..\Drivers\BSP\timer;..\..\Drivers\BSP\oled;..\..\Drivers\BSP\input_catch;..\..\Drivers\BSP\motor;..\..\Drivers\BSP\count;..\..\Drivers\BSP\encoder;..\..\Drivers\BSP\my_iic;..\..\Drivers\BSP\mpu6050;..\..\Drivers\BSP\pwm;..\..\Drivers\BSP\adc;..\..\Drivers\BSP\rain_sensor;..\..\Drivers\BSP\dht22;..\..\Drivers\BSP\bh1750;..\..\Drivers\BSP\bmp280
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/timer/: timer.c pwm.h
    ../../Drivers/BSP/pwm/: pwm.c
    ../../Drivers/BSP/oled/: oled.c oled.h oled_font.h
    ../../Drivers/BSP/input_catch/: input_catch.c input_catch.h
    ../../Drivers/BSP/count/: count.c count.h
    ../../Drivers/BSP/encoder/: encoder.c encoder.h
    ../../Drivers/BSP/my_iic/: my_iic.c my_iic.h
    ../../Drivers/BSP/bh1750/: bh1750.c bh1750.h
    ../../Drivers/BSP/adc/: adc.c adc.h
    ../../Drivers/BSP/rain_sensor/: bsp_raindrop.c bsp_raindrop.h
    ../../Drivers/BSP/dht22/: dht22.c dht22.h
    ../../Drivers/BSP/mpu6050/: mpu6050.c mpu6050.h mpu6050_register.h
    ../../Drivers/BSP/bmp280/: bmp280.c bmp280.h
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c main.h
    ../../Drivers/SYSTEM/uart1/: uart1.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
    ../../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_uart.h stm32f1xx_hal_usart.h
